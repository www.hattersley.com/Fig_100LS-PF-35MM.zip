# Autodesk Inventor part: Fig_100LS-PF-35MM
## iProperties
Created: 2011-12
Part Number: Fig_100LS-PF-35MM
Document SubType Name: Modeling
Designer: D Cole
Density: 1 g/cm^3
Author: D Cole
